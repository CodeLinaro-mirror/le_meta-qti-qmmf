FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"
SRC_URI += "file://0001-Stub-out-keyboard-handling-to-avoid-segfaulting.patch"
