# build this version in preference to others
DEFAULT_PREFERENCE = "1"

# libepoxy requires opengl
DISTRO_FEATURES_append = " opengl"
 
